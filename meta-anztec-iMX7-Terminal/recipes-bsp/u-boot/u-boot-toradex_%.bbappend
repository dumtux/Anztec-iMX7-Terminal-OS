# This is .bbappend file for linux-toradex for imx7d

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

#SRC_URI =+ "file://0001-uart-u-boot-change.patch"
